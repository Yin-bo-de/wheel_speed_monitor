/* ui_render 实现：见头文件注释。
 * 字形用经典 5×7 点阵（每字模 5 列，LSB 在上），大字按整数倍放大。 */
#include "ui_render.h"

#include <stdio.h>
#include <string.h>

/* ASCII 0x20..0x7E，每字符 5 列 */
static const uint8_t k_font5x7[95][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, /* ' ' */
    {0x00, 0x00, 0x5F, 0x00, 0x00}, /* ! */
    {0x00, 0x07, 0x00, 0x07, 0x00}, /* " */
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, /* # */
    {0x24, 0x2A, 0x7F, 0x2A, 0x12}, /* $ */
    {0x23, 0x13, 0x08, 0x64, 0x62}, /* % */
    {0x36, 0x49, 0x55, 0x22, 0x50}, /* & */
    {0x00, 0x05, 0x03, 0x00, 0x00}, /* ' */
    {0x00, 0x1C, 0x22, 0x41, 0x00}, /* ( */
    {0x00, 0x41, 0x22, 0x1C, 0x00}, /* ) */
    {0x14, 0x08, 0x3E, 0x08, 0x14}, /* * */
    {0x08, 0x08, 0x3E, 0x08, 0x08}, /* + */
    {0x00, 0x50, 0x30, 0x00, 0x00}, /* , */
    {0x08, 0x08, 0x08, 0x08, 0x08}, /* - */
    {0x00, 0x60, 0x60, 0x00, 0x00}, /* . */
    {0x20, 0x10, 0x08, 0x04, 0x02}, /* / */
    {0x3E, 0x51, 0x49, 0x45, 0x3E}, /* 0 */
    {0x00, 0x42, 0x7F, 0x40, 0x00}, /* 1 */
    {0x42, 0x61, 0x51, 0x49, 0x46}, /* 2 */
    {0x21, 0x41, 0x45, 0x4B, 0x31}, /* 3 */
    {0x18, 0x14, 0x12, 0x7F, 0x10}, /* 4 */
    {0x27, 0x45, 0x45, 0x45, 0x39}, /* 5 */
    {0x3C, 0x4A, 0x49, 0x49, 0x30}, /* 6 */
    {0x01, 0x71, 0x09, 0x05, 0x03}, /* 7 */
    {0x36, 0x49, 0x49, 0x49, 0x36}, /* 8 */
    {0x06, 0x49, 0x49, 0x29, 0x1E}, /* 9 */
    {0x00, 0x36, 0x36, 0x00, 0x00}, /* : */
    {0x00, 0x56, 0x36, 0x00, 0x00}, /* ; */
    {0x08, 0x14, 0x22, 0x41, 0x00}, /* < */
    {0x14, 0x14, 0x14, 0x14, 0x14}, /* = */
    {0x00, 0x41, 0x22, 0x14, 0x08}, /* > */
    {0x02, 0x01, 0x51, 0x09, 0x06}, /* ? */
    {0x32, 0x49, 0x79, 0x41, 0x3E}, /* @ */
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, /* A */
    {0x7F, 0x49, 0x49, 0x49, 0x36}, /* B */
    {0x3E, 0x41, 0x41, 0x41, 0x22}, /* C */
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, /* D */
    {0x7F, 0x49, 0x49, 0x49, 0x41}, /* E */
    {0x7F, 0x09, 0x09, 0x09, 0x01}, /* F */
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, /* G */
    {0x7F, 0x08, 0x08, 0x08, 0x7F}, /* H */
    {0x00, 0x41, 0x7F, 0x41, 0x00}, /* I */
    {0x20, 0x40, 0x41, 0x3F, 0x01}, /* J */
    {0x7F, 0x08, 0x14, 0x22, 0x41}, /* K */
    {0x7F, 0x40, 0x40, 0x40, 0x40}, /* L */
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, /* M */
    {0x7F, 0x04, 0x08, 0x10, 0x7F}, /* N */
    {0x3E, 0x41, 0x41, 0x41, 0x3E}, /* O */
    {0x7F, 0x09, 0x09, 0x09, 0x06}, /* P */
    {0x3E, 0x41, 0x51, 0x21, 0x5E}, /* Q */
    {0x7F, 0x09, 0x19, 0x29, 0x46}, /* R */
    {0x46, 0x49, 0x49, 0x49, 0x31}, /* S */
    {0x01, 0x01, 0x7F, 0x01, 0x01}, /* T */
    {0x3F, 0x40, 0x40, 0x40, 0x3F}, /* U */
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, /* V */
    {0x3F, 0x40, 0x38, 0x40, 0x3F}, /* W */
    {0x63, 0x14, 0x08, 0x14, 0x63}, /* X */
    {0x07, 0x08, 0x70, 0x08, 0x07}, /* Y */
    {0x61, 0x51, 0x49, 0x45, 0x43}, /* Z */
    {0x00, 0x7F, 0x41, 0x41, 0x00}, /* [ */
    {0x02, 0x04, 0x08, 0x10, 0x20}, /* \ */
    {0x00, 0x41, 0x41, 0x7F, 0x00}, /* ] */
    {0x04, 0x02, 0x01, 0x02, 0x04}, /* ^ */
    {0x40, 0x40, 0x40, 0x40, 0x40}, /* _ */
    {0x00, 0x01, 0x02, 0x04, 0x00}, /* ` */
    {0x20, 0x54, 0x54, 0x54, 0x78}, /* a */
    {0x7F, 0x48, 0x44, 0x44, 0x38}, /* b */
    {0x38, 0x44, 0x44, 0x44, 0x20}, /* c */
    {0x38, 0x44, 0x44, 0x48, 0x7F}, /* d */
    {0x38, 0x54, 0x54, 0x54, 0x18}, /* e */
    {0x08, 0x7E, 0x09, 0x01, 0x02}, /* f */
    {0x0C, 0x52, 0x52, 0x52, 0x3E}, /* g */
    {0x7F, 0x08, 0x04, 0x04, 0x78}, /* h */
    {0x00, 0x44, 0x7D, 0x40, 0x00}, /* i */
    {0x20, 0x40, 0x44, 0x3D, 0x00}, /* j */
    {0x7F, 0x10, 0x28, 0x44, 0x00}, /* k */
    {0x00, 0x41, 0x7F, 0x40, 0x00}, /* l */
    {0x7C, 0x04, 0x18, 0x04, 0x78}, /* m */
    {0x7C, 0x08, 0x04, 0x04, 0x78}, /* n */
    {0x38, 0x44, 0x44, 0x44, 0x38}, /* o */
    {0x7C, 0x14, 0x14, 0x14, 0x08}, /* p */
    {0x08, 0x14, 0x14, 0x18, 0x7C}, /* q */
    {0x7C, 0x08, 0x04, 0x04, 0x08}, /* r */
    {0x48, 0x54, 0x54, 0x54, 0x20}, /* s */
    {0x04, 0x3F, 0x44, 0x40, 0x20}, /* t */
    {0x3C, 0x40, 0x40, 0x20, 0x7C}, /* u */
    {0x1C, 0x20, 0x40, 0x20, 0x1C}, /* v */
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, /* w */
    {0x44, 0x28, 0x10, 0x28, 0x44}, /* x */
    {0x0C, 0x50, 0x50, 0x50, 0x3C}, /* y */
    {0x44, 0x64, 0x54, 0x4C, 0x44}, /* z */
    {0x00, 0x08, 0x36, 0x41, 0x00}, /* { */
    {0x00, 0x00, 0x7F, 0x00, 0x00}, /* | */
    {0x00, 0x41, 0x36, 0x08, 0x00}, /* } */
    {0x08, 0x04, 0x08, 0x10, 0x08}, /* ~ */
};

static void fb_clear(uint8_t fb[UI_FB_SIZE])
{
    memset(fb, 0, UI_FB_SIZE);
}

static void fb_set(uint8_t fb[UI_FB_SIZE], int x, int y)
{
    if (x < 0 || x >= UI_FB_W || y < 0 || y >= UI_FB_H) {
        return;
    }
    fb[(y / 8) * UI_FB_W + x] |= (uint8_t)(1u << (y & 7));
}

bool ui_fb_get_pixel(const uint8_t fb[UI_FB_SIZE], int x, int y)
{
    if (x < 0 || x >= UI_FB_W || y < 0 || y >= UI_FB_H) {
        return false;
    }
    return (fb[(y / 8) * UI_FB_W + x] >> (y & 7)) & 1u;
}

/* 在 (x,y) 处画字符（y 为字顶），scale 为放大倍数 */
static void draw_char(uint8_t fb[UI_FB_SIZE], int x, int y, char ch, int scale)
{
    if (ch < 0x20 || ch > 0x7E) {
        ch = '?';
    }
    const uint8_t *g = k_font5x7[ch - 0x20];
    for (int col = 0; col < 5; col++) {
        uint8_t bits = g[col];
        for (int row = 0; row < 7; row++) {
            if (!(bits & (1u << row))) {
                continue;
            }
            for (int dy = 0; dy < scale; dy++) {
                for (int dx = 0; dx < scale; dx++) {
                    fb_set(fb, x + col * scale + dx, y + row * scale + dy);
                }
            }
        }
    }
}

static void draw_text(uint8_t fb[UI_FB_SIZE], int x, int y, const char *s)
{
    for (; *s != '\0'; s++, x += 6) {
        draw_char(fb, x, y, *s, 1);
    }
}

/* 截断到 max_chars 再画（配置字符串可能超宽） */
static void draw_text_n(uint8_t fb[UI_FB_SIZE], int x, int y,
                        const char *s, int max_chars)
{
    int n = 0;
    for (; *s != '\0' && n < max_chars; s++, n++, x += 6) {
        draw_char(fb, x, y, *s, 1);
    }
}

static int draw_text_scaled(uint8_t fb[UI_FB_SIZE], int x, int y,
                            const char *s, int scale)
{
    int w = 0;
    for (; *s != '\0'; s++, x += 6 * scale, w += 6 * scale) {
        draw_char(fb, x, y, *s, scale);
    }
    return w;
}

/* 差速四态 → 屏幕短标签（ASCII：屏上中文字库成本高，标签一眼可辨即可） */
static const char *phase_label(bool en, telem_phase_t phase)
{
    if (!en) {
        return "OFF";
    }
    switch (phase) {
    case TELEM_PHASE_IDLE:
        return "UNLOCK";
    case TELEM_PHASE_PENDING_SYNC:
        return "WAIT";
    case TELEM_PHASE_PROBE:
        return "PROBE";
    case TELEM_PHASE_LOCKED:
        return "LOCK";
    default:
        return "--";
    }
}

void ui_render_main(const ui_view_t *v, uint8_t fb[UI_FB_SIZE])
{
    fb_clear(fb);

    /* 状态区第 1 行：生效模式（遥控接管也算生效模式） */
    char line[32];
    const char *mode = v->mode_valid ? (v->mode_auto ? "AUTO" : "MANUAL") : "--";
    snprintf(line, sizeof(line), "MODE %s", mode);
    draw_text(fb, 0, 0, line);

    /* 主信息：车速大字（3 倍 5×7 字模，字高 21px），单位跟在后面 */
    char num[8];
    if (v->speed_valid) {
        int kmh = (int)(v->speed_kmh + 0.5f);
        if (kmh < 0) {
            kmh = 0;
        } else if (kmh > 999) {
            kmh = 999;
        }
        snprintf(num, sizeof(num), "%d", kmh);
    } else {
        snprintf(num, sizeof(num), "--");
    }
    int w = draw_text_scaled(fb, 2, 12, num, 3);
    draw_text(fb, 2 + w + 4, 22, "km/h");

    /* 状态区第 2/3 行：前/后差速四态 */
    snprintf(line, sizeof(line), "F: %s",
             phase_label(v->phase_en[0], v->phase[0]));
    draw_text(fb, 0, 38, line);
    snprintf(line, sizeof(line), "R: %s",
             phase_label(v->phase_en[1], v->phase[1]));
    draw_text(fb, 0, 48, line);
}

void ui_render_disconnected(uint8_t fb[UI_FB_SIZE])
{
    fb_clear(fb);
    /* 断开标记：边框 + 居中文本，和正常画面一眼区分 */
    for (int x = 3; x < UI_FB_W - 3; x++) {
        fb_set(fb, x, 18);
        fb_set(fb, x, 45);
    }
    for (int y = 18; y <= 45; y++) {
        fb_set(fb, 3, y);
        fb_set(fb, UI_FB_W - 4, y);
    }
    const char *msg = "DISCONNECTED";
    int w = (int)strlen(msg) * 6 - 1;
    draw_text(fb, (UI_FB_W - w) / 2, 24, msg);
    const char *sub = "no telemetry";
    w = (int)strlen(sub) * 6 - 1;
    draw_text(fb, (UI_FB_W - w) / 2, 34, sub);
}

void ui_render_info(const ui_info_t *info, uint8_t fb[UI_FB_SIZE])
{
    fb_clear(fb);
    char line[40];

    draw_text(fb, 0, 4, "OLED SPEED MONITOR");

    snprintf(line, sizeof(line), "AP  %s",
             (info->ap_ssid != NULL) ? info->ap_ssid : "");
    draw_text_n(fb, 0, 16, line, 21);

    snprintf(line, sizeof(line), "CFG %s",
             (info->ap_ip != NULL) ? info->ap_ip : "");
    draw_text_n(fb, 0, 28, line, 21);

    snprintf(line, sizeof(line), "D %.1fmm DIS %.1fs",
             (double)info->diam_mm, (double)info->disconnect_ms / 1000.0);
    draw_text_n(fb, 0, 40, line, 21);

    /* 版本和 STA IP 并一行：IP 没拿到就显示 (waiting)，现场看连接状态 */
    snprintf(line, sizeof(line), "V%s %s",
             (info->version != NULL) ? info->version : "",
             (info->ip != NULL) ? info->ip : "(waiting)");
    draw_text_n(fb, 0, 52, line, 21);
}
