# Repository Yin-bo-de/wheel_speed_monitor

File README.md:

# wheel_speed_monitor

RC 攀爬车四轮转速监测验证台（v1）。

A3144 霍尔传感器 + 小铷磁铁随车轮转动触发脉冲，ESP32-S3 用 PCNT 硬件计数，
经 WebSocket 推送遥测帧到内嵌网页验证台。采集器框架可扩展（后续加 IMU 姿态等）。

## 硬件与接线

板卡：Freenove ESP32-S3 WROOM CAM（FNK0085），板载 DVP 摄像头与 8MB PSRAM。

| 轮 | 霍尔 GPIO | 说明 |
|---|---|---|
| 左前 | GPIO1 | |
| 右前 | GPIO14 | 闪光灯焊盘可选接口，不用 |
| 左后 | GPIO21 | |
| 右后 | GPIO47 | |

A3144 接线：VCC ← ESP32 3.3V（**注意：数据手册标称 4.5–24V，3.3V 低于规格下限，
可能工作但不保证**）、GND ← GND、OUT → GPIO 并 10kΩ 上拉到 3.3V（面板已加）。
磁铁南极靠近 → OUT 拉低（下降沿 = 一次触发）。

### 3.3V 供电排查预案

1. 打开验证台「原始 IO 电平监视」：
   - 静止时 4 路全"高" = 上拉有效；某路非高 → 查该路接线/上拉电阻。
   - 磁铁靠近时对应 GPIO 闪"低" = 触发正常。
2. 静止高、磁铁靠近不闪低 → 万用表量 A3144 VCC 对 GND 电压：
   - 不足 3.1V 且无动作 → **改 5V 供电**：VCC 改接 ESP32 5V 引脚；
     **输出上拉保持接 3.3V**（A3144 是开集电极，上拉电压决定 GPIO 高电平，安全）。
3. 翻转但 RPM 乱跳 → 磁铁南极面朝向传感器、间距 < 5mm；网页「去抖」填 20 开软件去抖。

## 差速舵机

前、后差速各接一个标准角度舵机（50Hz，脉宽 500–2500µs，1500µs 中位）。
信号线接 **GPIO41（前差速）** 和 **GPIO42（后差速）**。

自动模式下每个通道只有两个落点，各自可配：**解锁档**是正常行驶位置，
**锁定档**是差速锁死位置。差速器只有锁止和释放两个确定位置，中间行程没有意义，
所以不做连续的角度映射。前后轴分别配置——两轴舵机的安装朝向或连杆行程不同时，
各填各的行程端即可（比如后轴装反，就把它的锁定档填到另一端），不需要「反向」开关。

这两个脚在 ESP32-S3 上是 JTAG 引脚，但默认的调试通道是芯片内置的
USB-Serial-JTAG，它走芯片内部的 TAP 控制器，不占用这四个引脚，所以照用不误：
不用关 JTAG，不用改 console，烧录和 monitor 的用法一个字都不变。唯一会撞的
情况是有人烧了 `DIS_USB_JTAG` efuse 把 JTAG 引到引脚上。

舵机电源必须独立 5V 并与 ESP32 共地。堵转电流可能超过 1A，不要从板子的
3.3V 取电。

### 在验证台上验证（不接真舵机）

设置 tab 里勾上「模拟舵机模型」，执行器就换成软件模型：它按设定速率朝目标
脉宽移动，把"指令到哪、现在到哪、到没到"如实回传页面。轮速照旧用模拟模式喂，
整条判定链跟接了真舵机时走的是同一份代码。

能在验证台上复现的几件事：

| 想看的现象 | 怎么设 |
|---|---|
| 锁定差速 | 模拟转速设成左前 200、其余 60。前轴速差比例 0.7，超过 0.30 的门槛，前差速跳到锁定档 |
| 锁上后不被轮速带跑 | 锁定期间把左前改回 60，前差速继续锁着，不会马上松 |
| 试探与退避 | 保持时长（默认 3 秒）走完，状态变「试探中」、脉宽回解锁档。这时再制造打滑会立刻锁回，保持时长翻倍到 6 秒，再往后 12 秒，封顶 30 秒 |
| 退避复位 | 四个轮子都设成 60，或者全部停到 0。试探窗口走完就回到「已解锁」，保持时长复位成 3 秒 |

页面上的阶段徽章（已解锁 / 锁定中 / 试探中）和三段式状态机是一一对应的，
锁定保持时长的翻倍也在卡片上直接显示。

### 接真舵机

设置 tab 里取消勾选「模拟舵机模型」，执行器切成 LEDC 输出。轮速仍然可以用
模拟模式喂，这正是"用验证台的模拟轮速驱动真舵机"的用法。

拿示波器或逻辑分析仪量 GPIO41/42：应当是 50Hz 方波，脉宽等于页面显示的指令
值。通道关掉时引脚停在低电平、没有脉冲，舵机脱力。真实舵机的行程时间比模拟
模型慢，如果试探窗口（默认 2000ms）不够它走完，在设置页调大即可。

## 遥控输入（差速锁模式切换）

接收机三路 PWM 接 **GPIO38（模式通道）/ GPIO39（前差速）/ GPIO40（后差速）**，
50Hz、脉宽 500–2500µs，与舵机同一量程。这三根脚原本是板载 microSD 卡座：本项目
不用 SD，卡座让位；39/40 兼外部 JTAG 脚，与已在用的 41/42 是同一情况。

模式通道决定差速锁听谁。**≥1500µs 判手动**：前后差速通道的脉宽原样透传给舵机，
遥控给多少就输出多少；**<1500µs 判自动**：忽略遥控，仍按轮速走打滑状态机。

任一路超过 100ms 没收到脉冲即判丢信号（约 5 帧），**那一路单独回落设置页配置**：
模式通道掉了就按设置页的自动/手动，差速通道掉了就按该轴的手动目标滑杆。两路判定
互相独立，一根线松掉不连累另一根——车上最常见的故障就是信号线松脱。

### 在验证台上验证（不接接收机）

设置 tab 的「遥控模拟」卡：勾上开关等于接了一台一直在发脉冲的接收机，三个滑杆
就是三路通道的脉宽（步进 10，能精确停在 1490 与 1500）。监测 tab 的「遥控输入」
卡如实显示三路的值、是否有效、以及每根轴此刻吃的是透传值还是滑杆值。

| 想看的现象 | 怎么设 |
|---|---|
| 模式切换 | 打开模拟，模式通道滑到 1490 再滑到 1500，生效模式在自动/手动之间翻 |
| 手动透传 | 模式通道 1700（手动），前差速 1200 → 前轴指令 1200µs，后轴不受影响 |
| 自动忽略遥控 | 模式通道 1200（自动），拨动两根差速通道滑杆，两轴指令不跟着动 |
| 掉线回落 | 关掉模拟开关（等价接收机断电），三路变「无信号（N ms 前）」，模式与目标回落设置页配置 |

### 接真接收机

设置 tab 里把「遥控模拟」关掉（开着会把 GPIO38/39/40 上的真实信号盖掉），接收机
三根信号线接到 38/39/40，供电与 ESP32 共地。启动日志里应出现
`rccap: RC 捕获就绪 模式=GPIO38 前=39 后=40`。

接线前先确认接收机的 failsafe 行为：部分接收机失联时会输出预设值（比如固定
1500µs），从我们的超时判据看那是"信号一直有效"。这属于接收机侧配置，页面上的
通道值看得见。

## 画面回传（摄像头预览）

板载 DVP 摄像头（OV2640/OV5640，驱动按 PID 自动识别）通过 MJPEG over HTTP
回传，浏览器 `` 直接播放。叠加信息（轮速/舵机/遥控/系统）在浏览器里用
canvas 绘制，不烧进 JPEG，所以不额外吃 ESP32 的 CPU。

摄像头引脚：SCCB 4/5、VSYNC 6、HREF 7、PCLK 13、XCLK 15、
Y2..Y9 = 11/9/8/10/12/18/17/16；GPIO14 是霍尔，不属于摄像头。
摄像头和 PSRAM 需要 `sdkconfig.defaults` 里的 `CONFIG_SPIRAM*` 与
`CONFIG_CAMERA_CORE1`，少了 PSRAM 相机会初始化失败。

**什么时候开始采集**：默认策略「按需」——只有监测 tab 的预览流请求才启动相机。
手机连上热点、停在设置页都不采集。切到设置 tab 后流和采集保持 30 秒，
30 秒内切回不断流、不重新初始化；超过 30 秒才断流停采。页面关闭或流意外断开
走 30 秒宽限。设置页还可以选「常开」（调试，发热/功耗自己担）或「关闭」。

停采时驱动会先让 OV5640 进入软件掉电（`0x3008` bit6），再关闭 ESP32-S3 的
XCLK（GPIO15 拉低）。传感器不再成像、也不收时钟，温度应明显下降；但 PWDN
在板上固定为 `-1`，模组本身仍接 3.3V，只剩待机功耗。

**帧率**：设置页的帧率上限同时约束传感器采集和 MJPEG 发送。相机初始化后会
实测一次基准帧率，OV2640 通过调 CLKRC、OV5640 通过拉长 VTS 把采集降到目标值，
配置低帧率时不会仍然全速空转发热。推流过程中，服务端还会根据发送阻塞时间
自动降速（最低 5fps），网络恢复后逐步升回配置上限；页面的“自动降速”标注和
`sys.cam.fps_eff` 能直接看到当前值。

| 想看的现象 | 怎么设 |
|---|---|
| 按需启动 | 停在设置 tab，串口没有相机 init 日志；切到监测 tab 后出现 init 日志并出画面 |
| 切 tab 保持 | 切到设置 tab，页面状态显示「预览暂停，N 秒后停止」，30 秒内切回画面不中断 |
| 30 秒超时 | 切走超过 30 秒，服务端断流并 deinit；切回时重新 init |
| 停采降温 | 关掉预览页，等 30 秒宽限走完，串口出现 `sensor standby`、`xclk off` 和 `camera idle`；模组温度应明显下降 |
| 静态帧兜底 | 勾「静态帧模式」，弱网下用 1 秒一次的快照代替 MJPEG，叠加层照常刷新 |
| 采集侧降帧 | 把帧率上限从 15 改到 5，串口出现 `sensor fps calibrated`，`sys.cam.fps` 降到约 5；模组温度应低于 15fps 时 |
| 网络自动降速 | 用限速/弱网环境推流，串口出现 `network throttle`，页面标注“自动降速”；网络恢复后逐步回到上限 |
| 全屏查看 | 点「全屏」进入浏览器全屏，视频和叠加层一起铺满；按 Esc 或右上角「退出全屏」退出。不支持元素全屏的浏览器会退化为铺满视口 |
| 原始快照 | 点「原始快照 ⤓」下载当前 JPEG；相机按需待机时页面会自动等它启动 |
| 画面旋转 | 装车方向不对时点「左转 90°」「右转 90°」把预览转到正向；只转视频，叠加层保持屏幕方向，角度按设备存 localStorage |

## 构建与烧录

```bash
# 环境加载（每次新终端）
get_idf

# 首次（会联网拉 espressif/esp32-camera 到 managed_components/）
idf.py set-target esp32s3
idf.py build

# 烧录（端口先 ls /dev/cu.*）
idf.py -p /dev/cu.usbmodemXXX flash monitor
```

## 无线固件升级

第一次启用 OTA 要插一次 USB：分区表从单 app 改成双 OTA，bootloader 和分区表
都变了，这一步绕不过去。

```bash
idf.py -p /dev/cu.usbmodemXXX flash monitor
```

`idf.py flash` 会一并烧写新的分区表和 `ota_data_initial.bin`，不需要手动擦
otadata；NVS 分区偏移没变，原有的轮径、舵机等配置保留。

之后每次升级：

1. 改根目录 `CMakeLists.txt` 里的 `PROJECT_VER`；
2. `idf.py build`；
3. 连上 `wheel-bench` 热点，打开 `http://192.168.4.1/`；
4. 设置页最底部「固件升级」选 `build/wheel_speed_monitor.bin`，确认后等待设备重启。

新固件启动后要等 WiFi 和 httpd 都可用才会被标记为有效。起不来或反复重启会
自动回滚到上一版本。想主动退回上一版本，点卡片里的「回退到另一版本」。

升级中断、断电、镜像不合法都不会切换启动分区，设备继续跑旧固件。真要刷成砖，
插 USB 重新烧录即可。

## 使用

1. 烧录后手机/电脑连 WiFi 热点 `wheel-bench`（开放，无密码）。
2. 浏览器打开 `http://192.168.4.1`。
3. 页面顶部四个 tab：
   - **监测**：4 轮 RPM/线速度/频率/累计脉冲、轮速曲线、原始 IO 电平监视、
     差速舵机状态卡、遥控输入卡。
   - **图传**：MJPEG 画面与浏览器叠加层，切到本页才按需开相机。
   - **设置**：采集配置（磁铁数/轮径/EMA/去抖/每轮启用）、模拟模式转速、
     差速舵机的全部参数、遥控模拟（三路注入脉宽）、画面回传配置
     （策略/分辨率/画质/采集发送帧率上限/叠加项）、固件升级。
   - **日志**：实时日志尾流与历史文件浏览/搜索，见下一节。
4. 配置自动持久化到 NVS。「模拟模式」用合成数据跑完显示与计算链路，
   走的是和真实霍尔完全相同的那条数据链。

## 远程日志

设备把 ESP_LOGx 的输出同时留一份在板子上，页面的「日志」tab 能直接看，
不用再守着串口。

- **实时**：日志先进入 RAM 里的 256 行环形缓冲（约 58KB，放在 PSRAM），
  页面每秒增量拉取。设备端环满后挤掉最老的行，页面用灰色分隔行标出
  「丢失 N 行」，所以短暂离开不会无声漏掉一段。
- **历史**：esp_timer 每 2 秒把新日志追加到当前小时的文件；单文件封顶
  128KiB，所有文件总量超过 6MiB 就从最旧的删起，正在写的文件不删。
  设备是纯 AP 模式、自己上不了网，所以时间由浏览器打开控制台时通过
  WebSocket 对时。对过时的文件名是 `log_20261108_15.log`；还没人对时的
  时段用 `log_b0037_005.log`，表示第 37 次开机后的第 5 小时。
- **浏览与搜索**：`/api/logs/list` 列出文件，`/api/logs/file` 下载原文，
  关键词匹配、高亮和级别过滤都在浏览器里做，设备端不跑 grep。
- **升级**：OTA 写 flash 前会先把日志刷盘并暂停落盘，避免和固件写入交错；
  storage 分区不在升级范围内，日志会跨版本保留。

第一次启动时 storage 分区是空的，固件会格式化一次。如果分区里有数据却
挂载失败，固件不会自动格式化：历史日志原样保留，实时日志和串口照常，
只是新的日志不再落盘。

## 宿主机单元测试

```bash
cmake -S tests/native -B tests/native/build
cmake --build tests/native/build
ctest --test-dir tests/native/build --output-on-failure
```

纯逻辑层（数学、回绕判定、模拟源、采集框架、JSON 渲染、配置校验、差速状态机、
模拟舵机模型、遥控判定与仲裁、网络自适应帧率控制器、日志环形缓冲/文件名解析/
轮转与配额删除）在 macOS 用 clang + Unity 跑；
硬件层（PCNT、LEDC、GPIO 捕获、摄像头 DVP、NVS、WiFi）与页面是集成分层，
由板上验证台验证。

## 目录结构

```
main/           入口、配置、Web 服务、内嵌验证台页、相机生命周期/流任务、日志落盘
components/
  telemetry/    采集框架（注册表/采样泵/帧聚合），可扩展采集器
  wheel_speed/  轮速采集器实现（数学链/回绕/模拟源/JSON 渲染）
  wheel_sensor/ PCNT 硬件薄封装（A3144 4 路）
  strategy/     差速状态机（打滑判定/锁定保持/试探退避/脉宽映射）+ JSON 渲染
  servo_act/    舵机执行器接口 + 模拟模型（纯 C）
  servo_drv/    LEDC 硬件输出（IDF 依赖）
  rc_input/     遥控三路通道的判定与仲裁 + JSON 渲染（纯 C）
  rc_capture/   GPIO 双沿中断测遥控脉宽（IDF 依赖）
  camera_drv/   esp32-camera 薄封装（引脚/初始化/取帧/传感器帧率，IDF 依赖）
  cam_rate/     网络自适应帧率控制器（纯 C，宿主机可测）
  log_core/     日志环形缓冲/文件名解析/轮转与配额删除（纯 C，宿主机可测）
tests/native/   宿主机单测（clang + Unity + ctest）
```

## 扩展：新增采集器（如 IMU）

1. `telemetry.h` 的 `telem_type_t` 末尾加枚举值；
2. 实现 `telem_collector_ops_t`（init/sample/render/reset_baseline）；
3. `app_main` 里 `telem_register` 注册；
4. 前端 `applyFrame` 的 collectors 遍历加一个渲染函数。

协议约定：`sample` 每采样窗口调用一次（50ms），计算量须小；`render` 输出本类型
JSON 对象（不含外层包裹），字段名即前端协议，变更需前后端同步。

## 二期进展

- 画面回传与展示信息选择：已实现（MJPEG 预览、浏览器叠加、按需采集、快照）。
- 姿态（IMU）采集器：尚未实现；相机启用后 4/5 被 SCCB 占用，IMU 总线选型
  （共用 4/5 或让出 GPIO2/48）还没拍板，见 `docs/CAMERA_DESIGN.md` 3.1。

## v1 范围外

STA 联网、密码认证、移动端专项适配。

## KiCad design hardware/wheel_carrier/wheel_carrier.kicad_pcb

File hardware/README.md:

# 转接底板（硬件 v7：4 层板、霍尔 RC 滤波、四路舵机）

轮速监测台的转接底板：原理图 + PCB 布局布线，全部脚本生成。Freenove
ESP32-S3 WROOM CAM 开发板**正面朝上**插在底板的两个 20 针排母上（J1 对右排
IO43 列，J2 对左排 3V3 列），霍尔、舵机、遥控、电源的接线全部从底板的端子上走；
开发板全部 40 针另有 1:1 的扩展排针。板子 **96 × 98.5mm**、**4 层**、三个
M2.5 安装孔，继续落在嘉立创 100×100 打样档内。

v7 在 v6 基础上做了四件事：**4 层叠层**（In1 整面 GND、In2 三路电源分割）、
**四路霍尔统一加 1k + 100nF RC 低通**（右前 GPIO14 被相机 PCLK/XCLK 耦合的
毛刺在源头压掉）、**全板信号地过孔围栏**、**新增两路自控舵机 J10/J11**
（GPIO2/48，固件已带 LEDC bring-up，MPU6050 自动控制逻辑后续再做）。

- **图纸**：用 KiCad 打开 `wheel_carrier/wheel_carrier.kicad_pro`（双击即可）。
- **生成器**：`scripts/gen_schematic.py`（原理图）+ `scripts/gen_pcb.py`（PCB），
  内容全是脚本里的常量，改完重跑就出新版。
- **验证状态**：原理图 ERC **0 错误 0 警告**；PCB DRC **0 错误 0 警告 0 未连接**
  （含丝印/外框类，`--refill-zones --save-board` 后全零）；Gerber + 钻孔文件
  已导出（`wheel_carrier/wheel_carrier-gerber.zip`），含 **In1_Cu/In2_Cu** 两层。

## 这块板做什么

| 项目 | 说明 |
|---|---|
| 开发板封装 | 2 个 20 针排母（J1 顶排 = 开发板右排 IO43 列，J2 底排 = 左排 3V3 列），**正面插装** |
| 扩展排针 | **J13/J14 直连开发板全部 40 针（1:1）**；J15 电源条（2×8，BEC×2 / 5V×3 / 3V3×3 + 8 地） |
| 电调 / 油门 | J16 收电调的 3 针插头（BEC 进板）；油门信号经底板直通到 J17 → 接接收机油门通道 |
| 电源输入 | J12 两针螺丝端子进 **BEC 6~7.4V**（电调 BEC 输出），位置固定（装车线束基准） |
| +BEC 主路 | 防反接后分给：J3~J6 霍尔的 +V、J17、J15 的 BEC 针、C1 大电容、降压段 |
| 5V 降压 | LM2596T-5.0 + 47µH 电感 + 续流管 + 输入/输出电容，5V 供开发板和**四路**舵机 |
| 防倒灌 | D2 串在给开发板的支路上，USB 与底板供电互不倒灌 |
| 霍尔 ×4 | J3 左前 / J4 右前 / J5 左后 / J6 右后，脚序 **+V / GND / 信号**（对 A3144），各配 10k 上拉到 3.3V |
| 霍尔滤波 | 每路 **1k 串阻 R11~R14 + 100nF 对地 C5~C8**；上拉/指示灯在传感器侧，电容贴 MCU 引脚 |
| 霍尔指示 | 每路信号一个 330R + 红灯：**亮 = 磁铁触发**（信号被拉低），转起来能看到闪烁 |
| 舵机 ×4 | J7 前差速 / J8 后差速 / J10 自控 1 / J11 自控 2，+V 固定为板载 **5V** |
| 遥控 | J9 一个 3 针排针：1=模式 / 2=前差速 / 3=后差速，**只走信号**；接收机电源/地走 J17 |
| 大电容 | C1 1000µF/25V 兜输入母线；C4 1000µF/16V 兜 5V 舵机堵转 |
| 指示灯 | LED1 绿灯 = +BEC 已上电；LED6 绿灯 = 降压段有 5V 输出 |

接口脚序：**舵机 J7/J8/J10/J11 是 信号 / +5V / GND；霍尔 J3~J6 是 +V(BEC) /
GND / 信号（A3144 的 1=VCC、2=GND、3=OUT）；遥控 J9 只有三路信号，没有电源和地。**
信号脚的 GPIO 分配与固件 `main/wheel_config.h` 完全一致。

### 引脚映射（与固件 wheel_config.h 一致）

| 接口 | 接到开发板排针 | GPIO |
|---|---|---|
| 霍尔·左前 J3 | J1 第 3 针 | 1 |
| 霍尔·右前 J4 | J2 第 19 针 | 14 |
| 霍尔·左后 J5 | J1 第 17 针 | 21 |
| 霍尔·右后 J6 | J1 第 16 针 | 47 |
| 舵机·前差速 J7 | J1 第 6 针 | 41 |
| 舵机·后差速 J8 | J1 第 5 针 | 42 |
| 舵机·自控 1 J10 | J1 第 4 针 | 2 |
| 舵机·自控 2 J11 | J1 第 15 针 | 48 |
| 遥控 J9·1 模式 | J1 第 9 针 | 38 |
| 遥控 J9·2 前差速 | J1 第 8 针 | 39 |
| 遥控 J9·3 后差速 | J1 第 7 针 | 40 |
| 开发板 5V 输入 | J2 第 20 针 | — |
| 开发板 3.3V（上拉与指示取电） | J2 第 1 针 | — |
| 开发板 GND | J1 第 20 针 | — |

排针针号 1 从**远离 USB 口**的一端数起，四个 20 针排针的 1 脚都在最左端
（丝印上有实心三角标），每一针的网名（3V3 / IO4 / IO47…）都印在排针旁边，
装板前对一遍即可。J13/J14 的针号与 J1/J2 一一对应（J13 第 n 针 = J1 第 n 针，
J14 = J2），排针右端另有 J13=J1、J14=J2 标注。

### 扩展排针的用法与红线

将来固件要用新 GPIO（比如 IMU 的 I2C），把杜邦线插到 J13/J14 对应针上就行。
引出的脚跟排母是 1:1 并联的，接外设等于并联一支，原功能不受影响。但有几条红线：

| 引脚 | 情况 |
|---|---|
| 2 / 48 | **v7 起接自控舵机 J10/J11**；板载 LED 常亮/微闪、WS2812 乱闪属预期，不要再外接 |
| 35 / 36 / 37 | PSRAM 数据线，接任何外部电路都会把 PSRAM 弄坏（能拿表测，不能接东西） |
| 19 / 20 | 原生 USB 的 D-/D+。用 USB 口烧录/调试时不能接；改走 CH343 口烧录才可复用 |
| 0 / 3 / 45 / 46 | 启动模式脚：上电瞬间被采样，外部电路拉着它们会进不了正常启动 |
| 4–18 | 摄像头位（IO4/IO5 是 I2C）。要复用先拔摄像头排线；后续 IMU 只能与摄像头共用 IO4/IO5 |
| 43 / 44 | 板载 CH343 串口，占着烧录通道，别动 |

### 电源条（J15）与电调口（J16/J17）

- **J15 是 2×8 电源条**：电源排 8 针（西→东：**BEC、BEC、5V、5V、5V、3V3、3V3、3V3**），
  另一排 8 针全是对应的 GND——每一列「电源 + 地」相邻，两针的杜邦壳插一列就能给
  传感器供电。**v7 的电压顺序与 v6 相反（v6 是 3V3→BEC），接线前看丝印。**
- **J16 收电调的 3 针插头**：BEC 电压从这里进板（三针插头中间那根必是 +V，
  插反只会信号线和地线换位，电源接不反），油门信号也从这里进板。
- **J17 去接收机**：用三针杜邦线接到接收机的油门通道。板载直通走线把 J16/J17 的
  信号针连通——油门信号「过板」，但那根直通是纯铜走线，**板子不通电也照传信号**，
  主控不在线不会断油门；J17 的 +V 是接收机唯一的电源入口。
- **遥控 J9**：一个 3 针信号排针，1=模式、2=前差速、3=后差速；接收机的电源和地
  仍从 J17 取，接线时 J17 必须插上，否则三路信号没有参考地。v7 把 J9 摆在板中部
  （霍尔与 MCU 之间），丝印脚序照旧。
- 进电方式二选一（或都用）：J12 螺丝端子（粗线 / 大电流）或 J16（即插即用）。
  **同一时间只允许一个电源来源**——别把两路不同电源同时接进这两种入口。

## 设计决定的理由

**为什么升 4 层。** v6 是双层板，右前霍尔信号（GPIO14）被相机 PCLK/XCLK
（GPIO13/15）耦合出假脉冲，软件只能压到 ~5 RPM 的瞬时波动。v7 用四层板从
结构上解决：**In1 整面 GND** 给所有信号就近回流，**In2 三块电源平面**把
+BEC/+5V/+3V3 的大电流从表层挪走，F/B 两层留给信号和局部短接。代价是打样
价格从 100×100 双层档升到四层档，换来的是右前方这块心病和更稳的舵机大电流。

**In2 电源怎么分。** 顶带 `y<32.5` 是 +3V3（霍尔上拉/330R、J15 的 3V3 列）；
左下 L 形 `x<60,y>72` + 左侧带是 +BEC（J12/D1/C1、J16/J17、霍尔 +V）；
右下 L 形 + 右侧带是 +5V（LM2596 输出、四路舵机、J15 的 5V 列）。信号全在
F/B 两层，分割线不用给信号让路；跨分割的只有过孔，平面会按净距自动掏洞。
THT 电源/GND 焊盘全部 `zone_connect 2` 实心连平面，密集区不受花焊盘辐条限制。

**为什么要 RC 滤波、为什么电容贴 MCU。** 四路霍尔统一加 1k 串阻 + 100nF 对地：
fc≈1.6kHz，微秒级耦合毛刺被衰减约 1000 倍；测频只认下降沿，放电回路
1k+100nF 的 τ≈0.1ms，边沿依旧陡峭；上升沿被 10k 上拉拖慢约 2ms，只影响
电平监视，不影响 PCNT/测频。串阻放在传感器侧（HALL_x 与 GPIOx 之间），
**100nF 放在 MCU 侧**——线缆上耦合进来的噪声在进引脚之前被旁路掉；串阻兼作
MCU 引脚保护。若实测仍不够，串阻可换 4.7k（fc 340Hz）或电容换 1µF，同封装
换值不改板。

**为什么要地过孔围栏。** 沿 GPIO14 全链、IO13/IO15 引出段、四路霍尔、
七路舵机/遥控信号两侧按 2.54 间距布 0.6/0.3 GND 过孔，把信号线的回流路径
钉在走线旁边。围栏候选点对全部焊盘、安装孔、异网走线和已有过孔做净距过滤，
密集区天然跳空；共 289 个，DRC 复核零违规。钻径 0.3mm 板厂无压力。

**为什么 J10/J11 用 GPIO2/48。** 开发板只剩这两个脚能腾：2 原为板载 LED、
48 原为 WS2812。牺牲灯效换两路舵机输出，比动 45/46/0/3（上电敏感）或
35~37（PSRAM）、19/20（USB）安全得多。固件 `servo_drv` 扩了第二组
LEDC CHANNEL_4/5（同 TIMER_1，避开相机 XCLK 的 TIMER_0/CH0），上电即出
50Hz 中位 1500µs，示波器/真舵机都能验；MPU6050 自动控制逻辑后续再接
`servo_ledc_auto_set_us()`。

**电源条为什么是 2×8、每列配一根地。** 一根 2.54 针只插得下一根杜邦线——原版
4 针的电源口挂两个传感器就不够分。传感器真正费的是针位，所以把电源口扩成
2×8：8 路电源、8 根地按列配对。信号类的预留继续走 J13/J14 扩展排针。

**电调口（J16/J17）为什么让油门过板。** 电调的三针插头直接插板子，BEC 从口上进
（与 J12 同一个节点，粗线大电流仍旧可以走端子）；油门信号用板上直通走线送到 J17
再回接收机。代价是油门路径多了两个插头，换来的是接线只有两根（电调到板、板到
接收机），而且以后固件想读油门（油门 + 四轮速算滑移率）信号点就在板上。

**为什么把 40 针全部引出来。** 固件还在长（二期有 IMU），下一个功能用哪根脚
说不准；把没在用的脚也引到扩展排针，将来插线即用、不用重新打板。

**BEC 的 6/7.4V 不能直接进开发板，也不能直接进舵机。** 开发板 5V 脚是按 5V
设计的，7.4V 灌进去会烧板上的 5V 器件、还会倒灌 USB；普通舵机也只到 6V 左右。
所以板上用 **LM2596T-5.0** 做了一路真降压，配 47µH 电感、续流管、输入
（C3 220µF/25V）输出（C4 1000µF/16V）电容。v7 四路舵机都挂在这路 5V 上，
C4 保持 1000µF 兜堵转瞬时电流。

**6V 档时 5V 段会略低于 5.0V，属正常。** BEC 6V 经防反接二极管掉到约 5.6V，
LM2596 在这个压差下接近直通、输出大约 4.9~5.1V。

**霍尔供电走 BEC、信号上拉走 3.3V。** A3144 规格下限 4.5V，BEC 供电解决；
上拉电压 3.3V 决定 GPIO 高电平，开集电极输出对 ESP32 安全。

**霍尔指示灯的接法。** 每路信号从 3.3V 经 330R 串一个 LED 到信号脚：
信号被传感器拉低（磁铁靠近）时电流导通、灯亮；信号为高时 LED 两端等电位、
自动熄灭。电流约 4mA，在 A3144 的 20mA 灌电流能力之内。上拉和指示灯都在
1k 串阻的传感器侧，不受串阻影响。

**开发板供电串了第二只肖特基 D2。** 插着 USB 调程序时，5V 段和 USB 5V 会在开发
板上顶牛（互相倒灌）。串上之后两边都能单独供电。

**电源网络用标签、不摆电源符号。** 电源符号和同名标签混用会触发 ERC 的
same_local_global_label 警告；统一用标签表达。PWR_FLAG 只管让 ERC 认可母线有驱动源。

## PCB 设计要点

**叠层**（`gen_pcb.py` 的 `layer_and_setup`）：F.Cu / In1.Cu / In2.Cu / B.Cu，
1.6mm 总厚，按嘉立创 4 层标准叠层 JLC04161H-7628 写：外层 1oz、内层 0.5oz，
7628 半固化片 0.2104 + 芯板 1.065 + 0.2104（加两面 0.01 阻焊约 1.61mm）。内层层号
F=0、In1=4、In2=6、B=2 不是猜的：脚本用 KiCad 自带 pcbnew 生成一块 4 层参考板，
摘它的 `(layers ...)` 节点，再按官方模板重建 `(stackup ...)`。**第一次生成需要
KiCad 的 pcbnew Python 环境**（脚本里 `PCB_PY` 指向 KiCad.app 自带的 Python 3.9）。

**布局**（PLACEMENT 表，坐标为焊盘包围盒中心）：
- 顶部霍尔区四列（列距 18，从西到东 左前/左后/右后/右前）：每列是接口 →
  10k 上拉 / 330R+红灯 → 1k 串阻；100nF 贴 J1 引脚上方（C5~C8）。右前最东，
  远离 IO13/IO15 的引出车道。
- 中部两个 20 针排母把开发板架空；J13/J14 贴 J2 下方 5.08mm，扇出沿用
  v6 的"半间距错位车道"（J1.20 是 GND，四层板上直接靠 In1 平面省掉这根长线）。
- 右侧自上而下 J7/J8/J10/J11 四路舵机（列距 9mm），J15 电源条在它们上方；
  +5V/GND 直接吃 In2/In1 平面，只有信号要拉线。J9 遥控三针摆在霍尔与 MCU
  之间的空带，三针 x 恰好对齐 J1.7/8/9 的目标列，B 层垂直进焊盘。
- 左侧 J16/J17（电调/接收机油门直通）；底部电源区沿用 v6 紧凑摆位，
  J12 位置固定。

**布线**（TRACKS/VIAS）：
- F.Cu：霍尔本地链、MCU 侧电容、舵机/遥控源端、+BEC/+5V 局部电源；
  B.Cu：跨板长线（GPIO14 东缘、四路舵机横巷、J9 遥控三路直下、DEV_5V、电源 N 线）。
- 每条关键信号换层处显式打 via；GND 全部靠 In1/B 层平面，不靠表层长途回流。
- 地过孔围栏 289 个 GND 过孔，按信号折线两侧 1.0mm 偏置、2.54 间距，碰撞过滤见
  `fence_net()`。
- BEC 输入端（J12 → D1）用 1.5mm 主干宽度，两个拐角做 45° 倒角：这是整条供电
  路径里唯一的单点窄路，四路舵机堵转时不在这里发热。+BEC 顶干线/底部母线、
  +5V 主干、+3V3 的直角拐角同样做了 45° 斜切；信号线保持正交。
  左脊 y=6.35 那个角例外：45° 斜切会切进 (3.5,3.5) 安装孔的禁布区，故意保留直角。
- 每个过孔、每段净空都是对着 DRC 报告逐条磨出来的；改坐标前先跑 DRC。

**丝印**（`build_silk()`，140 条文字 + 4 个 1 脚三角标）：
- 接口旁印功能名 + GPIO（从网表取号，不手写）；霍尔标 +V / G / S，舵机标
  S / +V / G，遥控标 模 / 前 / 后，J15 每个电源列竖标电压；
- J1/J2/J13/J14 每针网名用 0.58 号字；`check_silk()` 逐条对焊盘开窗/板边/
  文字做包围盒检查，不通过直接构建失败。

**DRC 与导出的正确姿势**（顺序敏感）：

```bash
CLI=/Applications/KiCad/KiCad.app/Contents/MacOS/kicad-cli
python3 scripts/gen_pcb.py                        # 重新生成（未填铺铜）
"$CLI" pcb drc --refill-zones --save-board \
    --output /tmp/pcb_drc.rpt wheel_carrier/wheel_carrier.kicad_pcb   # 重填铺铜+存回
"$CLI" pcb export gerbers --output wheel_carrier/gerber/ wheel_carrier/wheel_carrier.kicad_pcb
"$CLI" pcb export drill --output wheel_carrier/gerber/ --format excellon \
    --excellon-units mm wheel_carrier/wheel_carrier.kicad_pcb
```

坑：`pcb drc` 不带 `--refill-zones` 时**不填铺铜**，GND 会报几十条假「未连接」；
带上 `--save-board` 才会把铺铜写回文件（gerber 也才有铜皮）。生成器重跑会清掉
铺铜，导出前记得再走一遍这个流程。

另一个坑：kicad-cli 的部分操作（导出/DRC）会把 `.kicad_pro` 重写成完整版，
顺手把 `lib_footprint_mismatch` 的降级忽略丢掉。`gen_pcb.py` 每次运行会自动
补回，别手工去跟它较劲。

**已知接受项**：
- `lib_footprint_mismatch` 已在 `.kicad_pro` 里降级忽略（我们有意改了位号字号
  和部分焊盘）；U1 的库盘按 1.4 等比放大（环 0.15），间距/孔径照库不动；
- J1/J2/J13/J14 脚名标注用 0.58 号字，`.kicad_pro` 的文字高度下限同步放到 0.55；
- J15 电压顺序与 v6 相反（BEC→3V3），接线看丝印；
- v7 的板载 LED/WS2812 引脚（2/48）已让给自控舵机，灯效异常属预期。

## BOM（50 个元件，全部直插，方便手焊）

| 位号 | 元件 | 封装 |
|---|---|---|
| J1, J2 | 1×20 排母 | PinSocket_1x20_P2.54mm_Vertical |
| J13, J14 | 1×20 排针（扩展） | PinHeader_1x20_P2.54mm_Vertical |
| J15 | 2×8 排针（电源条） | PinHeader_2x08_P2.54mm_Vertical |
| J3–J11, J16, J17 | 1×3 排针 ×11 | PinHeader_1x03_P2.54mm_Vertical |
| J12 | 2 位 5.0mm 螺丝端子 | MX126-5.0-02P（或同类 bornier） |
| U1 | LM2596T-5.0（固定 5V 降压） | TO-220-5_Vertical |
| L1 | 47µH 直插电感 | L_Radial_D10.0mm（Fastron 07P 或同类） |
| D1 | 1N5824 肖特基（5A，整板总电流含 5V 舵机支路） | D_DO-201AD |
| D2, D3 | D2：1N5822（3A）；D3：SB560（5A/60V，续流管） | D_DO-201AD |
| C1 | 1000µF/25V 电解 | CP_Radial_D10.0mm_P5.00mm |
| C3 | 220µF/25V 电解 | CP_Radial_D10.0mm_P5.00mm |
| C4 | 1000µF/16V 电解 | CP_Radial_D10.0mm_P5.00mm |
| C2, C5–C8 | 100nF 瓷片（C2 原有；C5~C8 为 v7 霍尔 RC） | C_Disc_D5.0mm |
| R1–R4 | 10k（霍尔上拉） | R_Axial_DIN0207（P10.16mm） |
| R11–R14 | 1k（v7 霍尔串阻） | 同上 |
| R5, R10 | 1.5k / 1k（电源指示限流；R5 为 BEC、R10 为 5V） | 同上 |
| R6–R9 | 330R（霍尔指示限流） | 同上 |
| LED1, LED6 | 5mm 绿色（BEC / 5V 指示） | LED_D5.0mm |
| LED2–LED5 | 5mm 红色（霍尔指示） | LED_D5.0mm |

> v6 删掉的 J10/J11 在 v7 以**自控舵机**身份回归（IO2/IO48，+5V/GND 与差速舵机
> 同源）。四路舵机共用板载 LM2596，3A 是芯片上限；换大舵机时要么另配 5V BEC，
> 要么重新评估这一路（见使用说明书第 6 节）。

## 改图纸的姿势

两条路，选一条：

1. **改常量重跑**（推荐，图纸进 git、每版可复现）：
   ```bash
   python3 scripts/gen_schematic.py          # 原理图：.kicad_sch / .kicad_sym / 工程文件
   python3 scripts/gen_pcb.py                # PCB：.kicad_pcb（导 gerber 前记得重填铺铜，见上）
   python3 scripts/reload_kicad.py           # 让 KiCad 里打开着的图纸立刻刷新（见下）
   ```
   布局常量、网络、元件表都在脚本顶部一节一节排好。
   刷新脚本走 KiCad 的 IPC API（「设置 → 插件」里启用后重启一次 KiCad 生效），
   等价于菜单 File → Revert。Revert 会丢弃界面上未保存的手工改动。
2. **直接在 KiCad 里改**：改完必须同步回脚本，否则下次重跑会被覆盖。同步走
   `kicad-sync` 技能（对话里输 `/kicad-sync`；工具在
   `~/.claude/skills/kicad-sync/scripts/`，是仓外的东西，换机器要带走）：
   `board_diff.py --vs-generated` 语义对比找出改动 → 改动翻译进脚本 →
   `rebuild.py` 重跑生成器、闭环核对（差异必须归零）、重出全部产物。

自检三件套（改完跑一遍）：

```bash
CLI=/Applications/KiCad/KiCad.app/Contents/MacOS/kicad-cli
"$CLI" sch erc --severity-all --output /tmp/erc.rpt wheel_carrier/wheel_carrier.kicad_sch
"$CLI" sch export pdf --output /tmp/sch.pdf wheel_carrier/wheel_carrier.kicad_sch
# PDF 转图目检：sips -s format png -Z 4400 /tmp/sch.pdf --out /tmp/sch.png
"$CLI" pcb drc --refill-zones --save-board --output /tmp/pcb_drc.rpt wheel_carrier/wheel_carrier.kicad_pcb
```

给后来人的提醒（全是实际踩过的坑）：
- 旋转 90° 摆放的器件，属性文字要写 90° 角度才会横排；KiCad 会把 180° 文字
  翻正并反转左右对齐——旋转件文字用「居中」定位最省心。
- PCB 封装的原点在 1 号焊盘上，不是器件中心：`PLACEMENT` 的坐标语义是
  「焊盘包围盒中心」，由脚本自动换算；手工加件时记住这个语义。
- **位号的 REF_MOVES 是封装局部坐标**，不是屏幕坐标；旋转 90°/270° 时
  `rot_off()` 的换算方向要先默写一遍（v7 的 J9/J15/C5~C8 都在这上面踩过）。
- 同网络的走线允许自然汇合，但**同层不同网在密集区必须换层**；换层点先查
  DRC 报告精确到 0.01mm 的坐标。
- 丝印文字压焊盘开窗会被阻焊裁掉：`check_silk()` 会拦下；它和 KiCad DRC
  是两道关，都要过。

## 本版明确没做的事

- MPU6050 自动控制逻辑：J10/J11 目前只做上电中位 bring-up，IMU 后续与
  摄像头共用 IO4/IO5 的 SCCB；
- 打样下单与回板焊接（下一步；gerber 已就绪）；
- 传感器/接收机侧的线束加工（沿用现有线材即可）；
- 舵机没有独立 5V BEC：四路舵机和开发板共用板上 LM2596，3A 是芯片上限；
- 保险丝、过压保护：建议在电池与 J12 之间外串 3~5A 保险丝。

Parts:
C1: 1000µF/25V; CP_Radial_D10.0mm_P5.00mm
C2, C5, C6, C7, C8: 100nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3: 220µF/25V; CP_Radial_D10.0mm_P5.00mm
C4: 1000µF/16V; CP_Radial_D10.0mm_P5.00mm
D1: 1N5824; D_DO-201AD_P15.24mm_Horizontal
D2: 1N5822; D_DO-201AD_P15.24mm_Horizontal
D3: SB560; D_DO-201AD_P15.24mm_Horizontal
J1: 开发板排母1·右排 IO43 列; PinSocket_1x20_P2.54mm_Vertical
J2: 开发板排母2·左排 3V3 列; PinSocket_1x20_P2.54mm_Vertical
J3: 霍尔·左前; PinHeader_1x03_P2.54mm_Vertical
J4: 霍尔·右前; PinHeader_1x03_P2.54mm_Vertical
J5: 霍尔·左后; PinHeader_1x03_P2.54mm_Vertical
J6: 霍尔·右后; PinHeader_1x03_P2.54mm_Vertical
J7: 舵机·前差速; PinHeader_1x03_P2.54mm_Vertical
J8: 舵机·后差速; PinHeader_1x03_P2.54mm_Vertical
J9: 遥控·三通道信号; PinHeader_1x03_P2.54mm_Vertical
J10: 舵机·自控1; PinHeader_1x03_P2.54mm_Vertical
J11: 舵机·自控2; PinHeader_1x03_P2.54mm_Vertical
J12: BEC 输入 6~7.4V; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
J13: 扩展·排母1(直连 J1/右排); PinHeader_1x20_P2.54mm_Vertical
J14: 扩展·排母2(直连 J2/左排); PinHeader_1x20_P2.54mm_Vertical
J15: 电源排针; PinHeader_2x08_P2.54mm_Vertical
J16: 电调·BEC输入; PinHeader_1x03_P2.54mm_Vertical
J17: 接收机·油门; PinHeader_1x03_P2.54mm_Vertical
L1: 47µH; L_Radial_D10.0mm_P5.00mm_Fastron_07P
LED1, LED6: 绿灯; LED_D5.0mm
LED2, LED3, LED4, LED5: 红灯; LED_D5.0mm
R1: 10k; R_0805_2012Metric
R2, R3, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6, R7, R8, R9: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10, R11, R12, R13, R14: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: LM2596T-5; TO-220-5_Vertical

Connections:
+3V3: J2.1 (3V3), J14.1, J15.11, J15.13, J15.15, R1.1, R2.1, R3.1, R4.1, R6.1, R7.1, R8.1, R9.1
+5V: C4.1, D2.2 (A), J7.2, J8.2, J10.2, J11.2, J15.5, J15.7, J15.9, L1.2, R10.1, U1.4 (FB)
+BEC: C1.1, C3.1, D1.1 (K), J3.1, J4.1, J5.1, J6.1, J15.1, J15.3, J16.2, J17.2, R5.1, U1.1 (VIN)
DEV_5V: C2.1, D2.1 (K), J2.20 (5V), J14.20
EN: J2.2 (EN), J14.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D3.2 (A), J1.20 (GND), J3.2, J4.2, J5.2, J6.2, J7.3, J8.3, J10.3, J11.3, J12.2, J13.20, J15.2, J15.4, J15.6, J15.8, J15.10, J15.12, J15.14, J15.16, J16.3, J17.3, LED1.1 (K), LED6.1 (K), U1.3 (GND), U1.5 (~ON/OFF)
GPIO1: C5.1, J1.3 (IO1), J13.3, R11.2
GPIO14: C8.1, J2.19 (IO14), J14.19, R14.2
GPIO21: C6.1, J1.17 (IO21), J13.17, R12.2
GPIO38: J1.9 (IO38), J9.1, J13.9
GPIO39: J1.8 (IO39), J9.2, J13.8
GPIO40: J1.7 (IO40), J9.3, J13.7
GPIO41: J1.6 (IO41), J7.1, J13.6
GPIO42: J1.5 (IO42), J8.1, J13.5
GPIO47: C7.1, J1.16 (IO47), J13.16, R13.2
HALL_LB: J5.3, LED4.1 (K), R3.2, R12.1
HALL_LF: J3.3, LED3.1 (K), R1.2, R11.1
HALL_RB: J6.3, LED5.1 (K), R4.2, R13.1
HALL_RF: J4.3, LED2.1 (K), R2.2, R14.1
IO0: J1.13 (IO0), J13.13
IO2: J1.4 (IO2), J10.1, J13.4
IO3: J2.12 (IO3), J14.12
IO4: J2.3 (IO4), J14.3
IO5: J2.4 (IO5), J14.4
IO6: J2.5 (IO6), J14.5
IO7: J2.6 (IO7), J14.6
IO8: J2.11 (IO8), J14.11
IO9: J2.14 (IO9), J14.14
IO10: J2.15 (IO10), J14.15
IO11: J2.16 (IO11), J14.16
IO12: J2.17 (IO12), J14.17
IO13: J2.18 (IO13), J14.18
IO15: J2.7 (IO15), J14.7
IO16: J2.8 (IO16), J14.8
IO17: J2.9 (IO17), J14.9
IO18: J2.10 (IO18), J14.10
IO19: J1.19 (IO19), J13.19
IO20: J1.18 (IO20), J13.18
IO35: J1.12 (IO35), J13.12
IO36: J1.11 (IO36), J13.11
IO37: J1.10 (IO37), J13.10
IO43: J1.1 (IO43), J13.1
IO44: J1.2 (IO44), J13.2
IO45: J1.14 (IO45), J13.14
IO46: J2.13 (IO46), J14.13
IO48: J1.15 (IO48), J11.1, J13.15
unnamed: D1.2 (A), J12.1
unnamed: D3.1 (K), L1.1, U1.2 (OUT)
unnamed: LED1.2 (A), R5.2
unnamed: LED2.2 (A), R6.2
unnamed: LED3.2 (A), R7.2
unnamed: LED4.2 (A), R8.2
unnamed: LED5.2 (A), R9.2
unnamed: LED6.2 (A), R10.2
THROTTLE: J16.1, J17.1

Notes on the sheet:
正面插装：J1 对开发板右排 IO43 列，J2 对左排 3V3 列；针号 1 在远离 USB 的一端
扩展排针 J13/J14 直连开发板全部 40 针（J13=J1、J14=J2）；J15 电源排针 BEC×2/5V×3/3V3×3
35/36/37=PSRAM，19/20=USB，0/3/45/46=启动脚：接外部电路前先看 README
J16 接电调（BEC 进板）；油门信号经底板直通到 J17，再回接收机油门通道；J17 给接收机供电
BEC 输入 6~7.4V：板上降到 5V 给开发板和舵机；霍尔、J16/J17 走 BEC 原电压
舵机：信号/5V/GND（J7/J8 差速、J10/J11 自控）；霍尔：+V/GND/信号（A3144）；遥控 J9：三路信号，无电源/地
霍尔指示灯：亮 = 磁铁触发（信号被拉低）；轮子转动能看到闪烁
v7：霍尔加 1k+100nF RC 低通（R11~R14/C5~C8，电容在 MCU 侧）；四路舵机共用板载 5V，大舵机请外置 BEC

Board: 4 copper layers, 96.0 x 98.5 mm, 50 parts (0 on the bottom side), 55 nets.

## Code that names these connections

File hardware/scripts/gen_schematic.py (part):

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    "1": "+3V3", "2": "EN", "3": "IO4", "4": "IO5", "5": "IO6", "6": "IO7",
    "7": "IO15", "8": "IO16", "9": "IO17", "10": "IO18", "11": "IO8", "12": "IO3",
    "13": "IO46", "14": "IO9", "15": "IO10", "16": "IO11", "17": "IO12",
    "18": "IO13", "19": "GPIO14", "20": "DEV_5V",
}
ROW_R_NETS = {
    "1": "IO43", "2": "IO44", "3": "GPIO1", "4": "IO2", "5": "GPIO42", "6": "GPIO41",
    "7": "GPIO40", "8": "GPIO39", "9": "GPIO38", "10": "IO37", "11": "IO36",
    "12": "IO35", "13": "IO0", "14": "IO45", "15": "IO48", "16": "GPIO47",
    "17": "GPIO21", "18": "IO20", "19": "IO19", "20": "GND",
}

# 右侧接口列：3 针接口从上到下。v7 行距 12.7→17.78，每路接口下方多留
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    ("J3", "霍尔·左前", "HALL_LF", 96.52, "hall"),
    ("J5", "霍尔·左后", "HALL_LB", 114.3, "hall"),
    ("J6", "霍尔·右后", "HALL_RB", 132.08, "hall"),
    ("J7", "舵机·前差速", "GPIO41", 149.86, "servo"),
    ("J8", "舵机·后差速", "GPIO42", 167.64, "servo"),
    ("J9", "遥控·三通道信号", "GPIO38", 185.42, "rc"),
    # v7 新增两路自控舵机：信号 = IO2 / IO48，+V 仍取板载 5V
    ("J10", "舵机·自控1", "IO2", 203.2, "servo"),
    ("J11", "舵机·自控2", "IO48", 220.98, "servo"),
]
# 遥控三通道只留一个 3 针信号排针：1=模式、2=前差速、3=后差速。
# 接收机的电源和地仍走 J17（油门直通口），这里不引出 +V/GND。
RC_PINS = (("1", "GPIO38"), ("2", "GPIO39"), ("3", "GPIO40"))
# 上拉电阻列（与各自接口同高）。v7 起上拉挂在霍尔侧 HALL_x：串阻只隔开
# MCU，不隔开传感器与上拉/指示灯。
PULLUP_X = 354.33
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                fp="Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical",
                props={"Reference": (2.54, -3.81, "left"), "Value": (-13.97, 3.81, "right")})
    for inst in (j16, j17):
        stub_label(inst, "1", "left", "THROTTLE")
        stub_label(inst, "2", "left", "+BEC")
        stub_label(inst, "3", "left", "GND")

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    for ref, value, sig, y, kind in CONN_ROWS:
        inst = place(ref, "Connector_Generic:Conn_01x03", value, (CONN_COL_X, y),
                     fp="Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical",
                     # 编号挪到器件右侧：左侧右对齐的"J3"正好跟"GPIO1"标签贴死
                     props={"Reference": (2.54, -3.81, "left"), "Value": (-13.97, 3.81, "right")})
        if kind == "hall":
            # A3144：1=VCC、2=GND、3=OUT；板上 1 脚接 +BEC
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    chain_hall_led("R8", "LED4", 381.0, 114.3, "HALL_LB", side="left")
    chain_hall_led("R9", "LED5", 365.76, 132.08, "HALL_RB", side="left")
    # 右侧三路 RC：横排在各自接口下方的空行
    hall_rc("R11", "C5", CONN_COL_X + RC_DX, 96.52, "HALL_LF", "GPIO1")
    hall_rc("R12", "C6", CONN_COL_X + RC_DX, 114.3, "HALL_LB", "GPIO21")
    hall_rc("R13", "C7", CONN_COL_X + RC_DX, 132.08, "HALL_RB", "GPIO47")

    # ---- 左侧：霍尔·右前 -----------------------------------------------------
    j4 = place("J4", "Connector_Generic:Conn_01x03", "霍尔·右前", J4_AT,
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               props={"Reference": (2.54, -3.81, "left"), "Value": (-13.97, 3.81, "right")})
    stub_label(j4, "1", "left", "+BEC")
    stub_label(j4, "2", "left", "GND")
    stub_label(j4, "3", "left", "HALL_RF")
    r2 = place("R2", "Device:R", "10k", R2_AT, fp=R_FP,
               props={"Reference": (2.54, -1.27, "left"), "Value": (2.54, 1.27, "left")})
    pin_label(r2, "1", "+3V3", "left")
    stub_label(r2, "2", "down", "HALL_RF")
    # 霍尔指示灯（右前）
    chain_hall_led("R6", "LED2", 88.9, 128.27, "HALL_RF", side="right")
    # 右前 RC：串阻电容放在 J4 西侧空白带
    hall_rc("R14", "C8", RC_RF_X, 134.62, "HALL_RF", "GPIO14")

    # ---- 电源区（底部） -------------------------------------------------------
    # BEC 输入端子：1=VIN 2=GND（电调 BEC 输出，6V 或 7.4V 档）
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               # 对齐语义不可靠，用「居中」定位放在器件上方空位
               props={"Reference": (0, -6.35, None), "Value": (0, -8.89, None)})
    add_wire(170.18, 251.46, 170.18, 252.73, "D2K-C2")
    add_label("DEV_5V", 170.18, 252.73, "right")
    c2 = place("C2", "Device:C", "100nF", (170.18, 256.54),
               fp="Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm",
               props={"Reference": (-2.54, -1.27, "right"), "Value": (-2.54, 1.27, "right")})
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